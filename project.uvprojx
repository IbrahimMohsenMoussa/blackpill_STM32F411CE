# Keil uVision project project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  asm misc: -Wno-unused-command-line-argument
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./src/: dio.asm main.asm port.asm rcc.asm hardware_config.inc stm32f411.inc SysTick.asm adc.asm bitmaps.asm brakes.asm DFPlayer.s DFPlayer_defs.s exti.asm font.inc i2c.asm keypad.asm rtc_driver.asm sh1106_driver.s stepper.asm timer.asm tof400f_driver.s UART1.s UART1_defs.s ui_driver.s mpu6050.asm
software components: CMSIS:CORE 6.1.1, Device:Startup 2.6.3
